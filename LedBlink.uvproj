# Keil uVision project LedBlink.uvproj, settings and files
target TM4C129GH6PM (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: LedBlink
  c flags: Optim=1
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_BLIZZARD_RB1
  c misc: --C99
  c include: D:\SD\TI\TivaWare_C_Series-2.1.0.12573
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group Source
    ./: main.c startup.s
  group Libs
    D:/SD/TI/TivaWare_C_Series-2.1.0.12573/driverlib/rvmdk/: driverlib.lib
